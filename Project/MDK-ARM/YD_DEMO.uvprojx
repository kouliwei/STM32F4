# Keil uVision project YD_DEMO.uvprojx, settings and files
target Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Test +hex
  c flags: Optim=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\BaseDrive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Cmsis
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c
  group Lib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_adc.c stm32f4xx_dma.c
  group BaseDrive
    ../../BaseDrive/: led.c test.c timer.c usart.c imu_data_decode.c packet.c common.c motor.c slidingmode.c adc.c gps.c
  group Doc
    ../Doc/: ReadMe.txt
software components: CMSIS:CORE 4.1.0
